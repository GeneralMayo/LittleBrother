# Keil uVision project mbed_blinky.uvproj, settings and files
target nRF51822AA (ARM-ADS)
  device: nRF51xxx Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: mbed_blinky +hex
  c flags: Optim=1
  c define: __CORTEX_M0,  TARGET_NRF51_DK,  TARGET_FF_ARDUINO,  TARGET_MCU_NRF51822,  TARGET_MCU_NORDIC_32K,  NRF51,  TARGET_CORTEX_M,  TARGET_LIKE_MBED,  TARGET_NRF51822,  ARM_MATH_CM0,  TOOLCHAIN_ARM_STD,  __MBED__=1,  MBED_BUILD_TIMESTAMP=1457751350.82,  TARGET_NORDIC,  TARGET_MCU_NRF51_32K,  TARGET_MCU_NRF51,  TARGET_M0,  TOOLCHAIN_ARM,  TARGET_LIKE_CORTEX_M0,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;  mbed;  mbed/TARGET_NRF51_DK;  mbed/TARGET_NRF51_DK/TARGET_NORDIC;  mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_MCU_NRF51822;  mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib;  mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk;  mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components;  mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries;  mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/crc16;  mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/scheduler;  mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nordic_sdk/components/libraries/util;  mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_8_0_0;  mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s130_nrf51822_1_0_0;  mbed/TARGET_NRF51_DK/TARGET_NORDIC/TARGET_MCU_NRF51822/TARGET_NRF51_DK;  mbed/TARGET_NRF51_DK/TOOLCHAIN_ARM_STD;
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: mbed/TARGET_NRF51_DK/TOOLCHAIN_ARM_STD/nRF51822.sct
  link misc: mbed/TARGET_NRF51_DK/TOOLCHAIN_ARM_STD/board.o
            
              mbed/TARGET_NRF51_DK/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_NRF51_DK/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_NRF51_DK/TOOLCHAIN_ARM_STD/startup_nRF51822.o
            
              mbed/TARGET_NRF51_DK/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_NRF51_DK/TOOLCHAIN_ARM_STD/system_nrf51.o
            
              mbed/TARGET_NRF51_DK/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    ./: main.cpp
